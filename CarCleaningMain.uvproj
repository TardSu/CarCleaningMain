# Keil uVision project CarCleaningMain.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M451VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS;.\M451Series\Include;.\Library\inc;..\CarCleaningMain
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./M451Series/Source/: system_M451Series.c
    ./M451Series/Source/ARM/: startup_M451Series.s
  group User
    ./: main.c
  group Application
    ./Application/: application_main.c
  group Interface
    ./Interface/: interface_screen.c interface_softserial1.c interface_uca.c interface_tk77.c interface_button.c interface_eeprom.c interface_buzzer.c interface_softserial2.c interface_display7seg.c interface_jq6500.c interface_rtc.c
  group Library
    ./Library/src/: uart.c sys.c clk.c gpio.c timer.c pwm.c rtc.c i2c.c fmc.c scuart.c eadc.c
